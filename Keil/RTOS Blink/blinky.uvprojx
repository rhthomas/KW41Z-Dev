# Keil uVision project blinky.uvprojx, settings and files
target CMSIS-DAP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKW41Z256xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: IRAM(0x1FFF8000,0x00010000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  group Source Files
    ./: main.c
target CMSIS-DAP-MTB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKW41Z256xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: as above
  output: blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
software components: RTOS:Config 9.0.0, RTOS:Core 9.0.0, RTOS:Heap 9.0.0, RTOS:Timers 9.0.0, CMSIS:CORE 5.0.2, Board Support:LED 1.0.0, Device:Startup 1.0.0
